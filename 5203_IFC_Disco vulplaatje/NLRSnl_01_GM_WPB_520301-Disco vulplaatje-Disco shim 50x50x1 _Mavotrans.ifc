Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-10-07T09:20:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 07 09:20:12 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{EFF375EB-A000-4B1A-824E-B4C3157ABA2C}\ifc * Database version: 5507 * Database creation date: Fri Oct 07 09:20:12 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 07 09:20:12 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 07 09:20:12 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum

# IfcBuildingElementProxy: NLRSnl_01_GM_WPB_5203-Disco vulplaatje-Disco shim _Mavotrans_R19-Rev0:520301_50x50x1, 520301
In: Level 0
Type - Material: Plastic_Transparant
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Breedte | Width (mm): 50 mm; Hoogte | Height (mm): 1 mm
Type - Fire Protection - Brandklasse | Fire classification: Niet getest | Not rated
Type - Identity Data - Artikelnummer | Article number: 520301; Beschrijving | Description: Disco vulplaatje 50 x 50 x 1 transparant | Disco shim 50 x 50 x 1 transparent; Laatste versie | Last version: 06-10-2022; Leverancier | Supplier: Mavotrans; Model: LOD400; NL-SfB code: 28; Opmerkingen | Comments: Voor het uitvullen van elemenenten, t.b.v. tijdelijke ondersteuning, niet permanent belastbaar en niet zwaar belastbaar | For justification of elements, for temporary support, not permanently loadable and not heavily loadable; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: T. Plat; Type Name: 520301_50x50x1; URL: https://mavotrans.nl/disco-vulplaatje.html; Verpakkingshoeveelheid | Sales packaging: verpakking = 480 stuks | packaging = 480 pieces; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Materiaal | Material: Kunststof | Plastic
Type - Other - Category: Generic Models; Family Name: NLRSnl_01_GM_WPB_5203-Disco vulplaatje-Disco shim _Mavotrans_R19-Rev0
Type - Visibility - 520301: yes; 520302: no; 520303: no; 520304: no; 520305: no; 520307: no
Type - Pset_ProductRequirements - Category: Generic Models
Description: Disco vulplaatje 50 x 50 x 1 transparant | Disco shim 50 x 50 x 1 transparent; Classification: 28 (Default Classification)
Pset_BuildingElementProxyCommon - Reference: NLRSnl_01_GM_WPB_5203-Disco vulplaatje-Disco shim _Mavotrans_R19-Rev0:520301_50x50x1; sets with these values: 2
Pset_ProvisionForVoid - Width: 1 mm; Depth: 1 mm
Constraints - Level: Level: Level 0; Offset: 0 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.0141504 m2; Volume: 0.0000400131 m3
Other - Family: NLRSnl_01_GM_WPB_5203-Disco vulplaatje-Disco shim _Mavotrans_R19-Rev0: 520301_50x50x1; Family and Type: NLRSnl_01_GM_WPB_5203-Disco vulplaatje-Disco shim _Mavotrans_R19-Rev0: 520301_50x50x1; Schedule Level: Level: Level 0; Type: NLRSnl_01_GM_WPB_5203-Disco vulplaatje-Disco shim _Mavotrans_R19-Rev0: 520301_50x50x1; Type Id: NLRSnl_01_GM_WPB_5203-Disco vulplaatje-Disco shim _Mavotrans_R19-Rev0: 520301_50x50x1
Phasing - Phase Created: New Construction
